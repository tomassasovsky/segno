# Bundle inspection consumes RAUC's JSON metadata before do_deploy.
PACKAGECONFIG:append = " json"
